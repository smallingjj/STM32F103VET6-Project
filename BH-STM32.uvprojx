# Keil uVision project BH-STM32.uvprojx, settings and files
target GSM_GPRS (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\..\Libraries\CMSIS;..\..\User;..\..\Libraries\FWlib\inc;..\..\User\usart;..\..\User\sdcard;..\..\User\ff9;..\..\User\uart;..\..\User\adc;..\..\User\led;..\..\User\Key;..\..\User\WYX_OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../../Libraries/CMSIS/startup/: startup_stm32f10x_hd.s
  group CMSIS
    ../../Libraries/CMSIS/: core_cm3.c core_cm3.h stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group FWLB
    ../../Libraries/FWlib/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group USER
    ../../User/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_it.h bell.c bell.h
    ../../User/sdcard/: bsp_sdio_sdcard.c bsp_sdfs_app.c
    ../../User/SysTick/: bsp_SysTick.c
    ../../User/Key/: bsp_key.c bsp_key.h
    ../../User/usart/: bsp_usart.c
    ../../User/gsm_gprs/: bsp_gsm_gprs.c bsp_gsm_usart.c
    ../../User/adc/: dsp_adc.c dsp_adc.h
    ../../User/dht11/: bsp_dht11.c bsp_dht11.h
    ../../User/dwt_delay/: core_delay.c core_delay.h
    ../../User/led/: bsp_led.c bsp_led.h
    ../../User/WYX_OLED/: WYX_OLED.c OLED_Font.h WYX_OLED.h
  group ff9
    ../../User/ff9/: diskio.c ff.c
    ../../User/ff9/option/: cc936.c
  group DOC
    ../../Doc/: readme.txt
